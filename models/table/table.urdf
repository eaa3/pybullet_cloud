Commit message: adding boris arm and pisa hand

File: models/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link table_body: geometry collision box size=0.87 1.77 0.025; visual mesh filename=table.obj scale=0.87 1.77 0.025
